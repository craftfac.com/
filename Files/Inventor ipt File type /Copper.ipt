# Autodesk Inventor part: Copper
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2024-03
Part Number: Copper
Material: Generic
Document SubType Name: Modeling
Designer: AdminForWorker
Density: 1 g/cm^3
Appearance: Default
Title: Copper
Author: AdminForWorker
## Design history (mm, degrees)
feature "Copper"
body "Solid1"
